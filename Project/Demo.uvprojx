# Keil uVision project Demo.uvprojx, settings and files
target TemplateSTM32F4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo.elf +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\hardware\GPIO;..\hardware\OLED;..\hardware\delay;..\hardware\usart;..\hardware\Timer;..\hardware\PID;..\User;..\middleware\FreeRTOS\include;..\middleware\FreeRTOS\portable\RVDS\ARM_CM4F;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c misc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group User
    ../User/: stm32f4xx_it.c main.c
  group hardware
    ../hardware/GPIO/: GPIO.c
    ../hardware/OLED/: OLED.c sys.c
    ../hardware/delay/: Delay.c
    ../hardware/usart/: Serial.c Serial2.c Serial2.h Serial3.c Serial3.h
    ../hardware/Timer/: Timer.c
    ../hardware/PID/: PID.c PID.h
  group middleware/FreeRTOS_CORE
    ../middleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group middleware/FreeRTOS_PORT
    ../middleware/FreeRTOS/portable/MemMang/: heap_4.c
    ../middleware/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 6.1.0
